<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.5'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>apt</value></param>
<param><key>title</key><value>APT Receiver</value></param>
<param><key>author</key><value>Barnaby Shearer</value></param>
<param><key>description</key><value>RTL-SDR NOAA APT Receiver</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dec_filter_taps</value></param>
<param><key>value</key><value>firdes.low_pass(1, audio_rate, 4160/2, 4160/40)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>recfile</value></param>
<param><key>value</key><value>prefix + datetime.now().strftime("%Y.%m.%d.%H.%M.%S")</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>prefix</value></param>
<param><key>value</key><value>"/tmp/"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tune_filter_taps</value></param>
<param><key>value</key><value>firdes.low_pass(1, samp_rate, cutoff, trans, firdes.WIN_HAMMING, 6.76)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_filter_taps</value></param>
<param><key>value</key><value>firdes.low_pass(1, samp_rate, audio_cut, audio_trans, firdes.WIN_HAMMING, 6.76)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_rate</value></param>
<param><key>value</key><value>44100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>audio_rate*24</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>trans</value></param>
<param><key>label</key><value>Trans</value></param>
<param><key>value</key><value>10000</value></param>
<param><key>start</key><value>1</value></param>
<param><key>stop</key><value>samp_rate/2</value></param>
<param><key>step</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>9,0</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>offset_fine</value></param>
<param><key>label</key><value>Fine Tune</value></param>
<param><key>value</key><value>0</value></param>
<param><key>start</key><value>-2000</value></param>
<param><key>stop</key><value>2000</value></param>
<param><key>step</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>7,0</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>freq</value></param>
<param><key>label</key><value>         Select Sat</value></param>
<param><key>type</key><value>int</value></param>
<param><key>num_opts</key><value>4</value></param>
<param><key>value</key><value>99300000</value></param>
<param><key>option0</key><value>137620000</value></param>
<param><key>label0</key><value>NOAA 15</value></param>
<param><key>option1</key><value>137912500</value></param>
<param><key>label1</key><value>NOAA 18</value></param>
<param><key>option2</key><value>137100000</value></param>
<param><key>label2</key><value>NOAA 19</value></param>
<param><key>option3</key><value>99300000</value></param>
<param><key>label3</key><value>Test</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>gui_hint</key><value>0,1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>bb_gain</value></param>
<param><key>value</key><value>0</value></param>
<param><key>start</key><value>-100</value></param>
<param><key>stop</key><value>100</value></param>
<param><key>step</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>4,1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>if_gain</value></param>
<param><key>value</key><value>100</value></param>
<param><key>start</key><value>-100</value></param>
<param><key>stop</key><value>100</value></param>
<param><key>step</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>3,1</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>args</key><value></value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>freq0</key><value>freq-centeroff</value></param>
<param><key>dc_offset_mode0</key><value>2</value></param>
<param><key>iq_balance_mode0</key><value>1</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>gain0</key><value>rf_gain</value></param>
<param><key>if_gain0</key><value>if_gain</value></param>
<param><key>bb_gain0</key><value>bb_gain</value></param>
<param><key>bw0</key><value>samp_rate</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value></value></param>
<param><key>fftsize</key><value>512</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>bw</key><value>cutoff*2</value></param>
<param><key>update_time</key><value>0.2</value></param>
<param><key>gui_hint</key><value>tab@0</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>affinity</key><value>2</value></param>
</block>
<block>
<key>analog_wfm_rcv</key>
<param><key>id</key><value>analog_wfm_rcv_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>quad_rate</key><value>samp_rate</value></param>
<param><key>audio_decimation</key><value>samp_rate/audio_rate</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>freq-centeroff</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>gui_hint</key><value>0,0,5,1</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>affinity</key><value>2</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>centeroff</value></param>
<param><key>value</key><value>samp_rate/4</value></param>
<param><key>start</key><value>-samp_rate/2</value></param>
<param><key>stop</key><value>samp_rate/2</value></param>
<param><key>step</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>1,1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rf_gain</value></param>
<param><key>value</key><value>100</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>100</value></param>
<param><key>step</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>2,1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>offset_course</value></param>
<param><key>label</key><value>Coarse Tune</value></param>
<param><key>value</key><value>0</value></param>
<param><key>start</key><value>-centeroff</value></param>
<param><key>stop</key><value>centeroff</value></param>
<param><key>step</key><value>1000</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>6,0</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>cutoff</value></param>
<param><key>label</key><value>Cuttoff</value></param>
<param><key>value</key><value>40000</value></param>
<param><key>start</key><value>samp_rate/64</value></param>
<param><key>stop</key><value>samp_rate/2</value></param>
<param><key>step</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>8,0</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tab</value></param>
<param><key>num_tabs</key><value>2</value></param>
<param><key>label0</key><value>Waterfall</value></param>
<param><key>label1</key><value>Freq</value></param>
<param><key>gui_hint</key><value>6,1,5,1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>deviation</value></param>
<param><key>value</key><value>22000</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>75000</value></param>
<param><key>step</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>11,1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>audio_trans</value></param>
<param><key>value</key><value>11025/16</value></param>
<param><key>start</key><value>50</value></param>
<param><key>stop</key><value>audio_rate/2</value></param>
<param><key>step</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>12,1</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fftsize</key><value>512</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>bw</key><value>cutoff*2</value></param>
<param><key>ymin</key><value>-200</value></param>
<param><key>update_time</key><value>0.2</value></param>
<param><key>gui_hint</key><value>tab@1</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>affinity</key><value>2</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0_0</value></param>
<param><key>samp_rate</key><value>11025</value></param>
<param><key>device_name</key><value>pulse</value></param>
<param><key>ok_to_block</key><value>False</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_0</value></param>
<param><key>type</key><value>fff</value></param>
<param><key>interp</key><value>11025</value></param>
<param><key>decim</key><value>audio_rate</value></param>
<param><key>taps</key><value></value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>audio_cut</value></param>
<param><key>value</key><value>11025/2-audio_trans</value></param>
<param><key>start</key><value>1</value></param>
<param><key>stop</key><value>audio_rate/2</value></param>
<param><key>step</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from datetime import datetime</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>tune_filter_taps</value></param>
<param><key>center_freq</key><value>centeroff+offset_course+offset_fine</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>affinity</key><value>0</value></param>
</block>
<block>
<key>freq_xlating_fft_filter_ccc</key>
<param><key>id</key><value>freq_xlating_fft_filter_ccc_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>tune_filter_taps</value></param>
<param><key>center_freq</key><value>centeroff+offset_course+offset_fine</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>nthreads</key><value>5</value></param>
<param><key>affinity</key><value>0</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0</value></param>
<param><key>gain</key><value>samp_rate/(2*math.pi*deviation)</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0</value></param>
<param><key>type</key><value>fff</value></param>
<param><key>decim</key><value>samp_rate/audio_rate</value></param>
<param><key>taps</key><value>audio_filter_taps</value></param>
</block>
<block>
<key>blocks_wavfile_sink</key>
<param><key>id</key><value>blocks_wavfile_sink_0</value></param>
<param><key>file</key><value>recfile + ".wav"</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
<param><key>bits_per_sample</key><value>16</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>fftsize</key><value>512</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>bw</key><value>audio_rate*2</value></param>
<param><key>ymin</key><value>-200</value></param>
<param><key>ymax</key><value>0</value></param>
<param><key>update_time</key><value>.2</value></param>
<param><key>gui_hint</key><value>11,0,5,1</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>affinity</key><value>2</value></param>
</block>
<block>
<key>blocks_wavfile_sink</key>
<param><key>id</key><value>blocks_wavfile_sink_0_0</value></param>
<param><key>file</key><value>recfile + "-11.wav"</value></param>
<param><key>samp_rate</key><value>11025</value></param>
<param><key>bits_per_sample</key><value>16</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>src + '.dat'</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>audio_rate/4160</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>interp</key><value>4160</value></param>
<param><key>decim</key><value>audio_rate</value></param>
<param><key>taps</key><value>dec_filter_taps</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_0</value></param>
<param><key>type</key><value>fcc</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>dec_filter_taps</value></param>
<param><key>center_freq</key><value>2400</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
</block>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fft_filter_ccc_0</source_block_id><sink_block_id>qtgui_freq_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fft_filter_ccc_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>analog_wfm_rcv_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fft_filter_ccc_0</source_block_id><sink_block_id>analog_wfm_rcv_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>freq_xlating_fft_filter_ccc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fft_filter_ccc_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_wfm_rcv_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>blocks_wavfile_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>rational_resampler_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0</source_block_id><sink_block_id>blocks_wavfile_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0</source_block_id><sink_block_id>audio_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
